Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: e894146a-4833-4a84-92aa-b003607abd5d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 1669NU(2025).ifc
Time: 2025-05-20T22:45:01
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_347646_4
InPort_347646_5

# IfcFlowController: 1669NU(2025):1669NU Shower faucet with shower set, 1669NU(2025):1669NU Shower faucet with shower set:347646
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - General - Author: BIMStone; BIMObjectName: 1669NU(2025); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1111; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822); URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/1669NU; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/1669NU; VVS Number: 722262934
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Backflow Prevention EN1717: EB; Connection: Eccentric coupling(s); Connection Size: G1/2; Eco Flow At 300kPa: 0.16 dm3/s; Flow Rate At 300kPa: 0.19 dm3/s; Hand Shower Size: Ø 90 mm; Installation Type: Wall mounted; Installation Width: 150 ± 15 mm; Lever Handle: Temperature control handle;Flow control handle;Eco feature for water flow;Safety feature for water temperature; Max. Hot Water Supply: 65 C; Mechanical Parts: Ceramic head part for flow control;Non-return valve(s);Litter filter(s);Thermostatic cartridge for automatic temperature control; Shower Parts: Hand shower;Shower rail;Shower hose (1500 mm);Eco flow control; Shower Spray: Normal - Even and soft water stream;Refreshing - Strong water stream, activates and refreshes body;Relaxing - Soft water stream, pleasant for entire body; Shower Spray Number: 3 spray functions; Surface treatment: Chrome; Temperature: Thermostatic temperature control; Temperature Adjustments: The housing of the fittings conducts minimal heat;Safety stop against scalding at 38°C; Working Pressure: 100 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Dimensions - FaucetNominalDepth: 107.628 mm; FaucetNominalHeight: 70.4 mm; FaucetNominalWidth: 290 mm; HandShowerNominalDepth: 127.013 mm; HandShowerNominalHeight: 700 mm; HandShowerNominalWidth: 141.681 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/1669NU; Ambience photo: http://static.oras.com/ambience/1669NU; Catalog Drawing URL: http://static.oras.com/catdrw/1669NU; Category B2C: Shower solutions; Dimension Drawing URL: http://static.oras.com/dimdrw/1669NU; FDV Document URL: http://www.oras.com/datasheet/1669NU/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1669NU; Group: ShowerFaucetsWithShowerSet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1669NU; Interactive AR View URL: https://static.oras.com/AR/1669NU; Long Marketing: Introducing this Oras Linea thermostat with shower set - a timeless choice for every modern bathroom. Featuring a sleek chrome finish and wall-mounted installation type, this faucet set not only comes with a universal design but also offers outstanding price-performance ratio. The temperature and flow control handle allow for easy adjustments, while the eco and safety features for water temperature ensure efficiency and safety. Enjoy a variety of shower spray types with the 3-spray functions, complete with a hand shower, shower rail and shower hose. Choose the Linea line for daily enjoyment in everyday use. 7460U Shower thermostat 1690N Shower set; Manufacturer: Oras; Market: International;Denmark;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/1669NU; Model: 1669NU Shower faucet with shower set; Name_en: 1669NU Shower faucet with shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1669NU; Product Family: Oras Linea; Product Image URL: http://static.oras.com/image/1669NU; Product URL: http://static.oras.com/1669NU; Technical DataSheet URL: http://www.oras.com/datasheet/1669NU/en; Type Name: 1669NU Shower faucet with shower set; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1669NU(2025); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 1669NU; Name: 1669NU Shower faucet with shower set; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 290x110x70 mm; Shower: 140x130x700 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Material: <Unnamed>, Brass
Constraints - DistanceX-Axis: 300 mm; DistanceY-Axis: 300 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerVisibility: yes; Host: Level : Level 0; Level: Level 0; Offset from Host: 0 mm; ShowerDefaultElevation: 1200 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Dimensions - Area: 0.268918 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0148241 m3
Identity Data - Mark: 12
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1669NU(2025); Family and Type: 1669NU(2025): 1669NU Shower faucet with shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1669NU Shower faucet with shower set; Type Id: 347630; WarrantyStartDate: n/a
